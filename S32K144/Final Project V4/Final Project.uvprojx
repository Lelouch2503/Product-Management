# Keil uVision project Final Project.uvprojx, settings and files
target Final Prj V2 (6140000::V6.14::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\LIB;.\Protocol;..\Final Project V2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c Systick_Delay.c clock.c gpio.c flash.c nvic.c
  group Protocol
    ./Protocol/: LPSPI.c I2C.c LPUART.c
  group LIB
    ./LIB/: i2c-lcd.c mfrc522.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
